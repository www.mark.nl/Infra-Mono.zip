Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2017-11-01T15:45:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 01 15:45:00 2017 * Host: B3ROBRAWR3331 * Database: C:\Users\RVI\AppData\Local\Temp\{2352AD4B-8066-40F3-B0A5-06847C01C451}\ifc * Database version: 5507 * Database creation date: Wed Nov 01 15:44:56 2017 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Nov 01 15:44:56 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 01 15:44:56 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcSpaceHeater: INFRA MONO 30-12, HC_Radiant Heater_MEPcontent_Mark_Infra Mono_INT-EN:INFRA MONO 30-12:1291002
In: V00
Type - PredefinedType: CONVECTOR; Material: Color RGB - 193-193-194
Type - Dimensions - Diameter 1: 80 mm; Diameter 2: 80 mm; Length: 11973 mm; Width: 402.5 mm
Type - Electrical - Voltage: 230 V
Type - Electrical - Loads - Power: 0 W
Type - Identity Data - Article Description: Waterproof stainless steel Infra Mono; Article Type: INFRA MONO 30-12; Content Supplier URL: www.mepcontent.eu; Copyright: © Trimble Europe BV; Custom: no; Description: Waterproof stainless steel Infra Mono; EMCS Version: 3.0; ETIM Article Class: EC000535; Family Version: 11.06; GTIN: 87193332514105; Manufacturer: Mark; Manufacturer Art. No.: 5025141; Manufacturer URL: http://www.markclimate.com/radiant-heating/gas-fired/infra/; MEPcontent Class: RADIANT_HEATER; Model: INFRA MONO 30-12; OmniClass Number: 23.75.70.17.17; OmniClass Title: Radiation Panels; Product Line: Mark; Revit Version: 2018; Type Name: INFRA MONO 30-12; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Grey: Color RGB - 193-193-194
Type - Mechanical - Heating Power: 296008
Type - Other - Category: Mechanical Equipment; Angle Formula: 0 mm; Bend Length: 251 mm; Body Length: 2935 mm; Body Thickness: 10 mm; Connections Offset: 80 mm; Default Height: 172 mm; Diameter 1 Half: 40 mm; Diameter 2 Half: 40 mm; Family Name: HC_Radiant Heater_MEPcontent_Mark_Infra Mono_INT-EN; Fifth Bracket: 2725 mm; First Bracket: 540 mm; Fourth Bracket: 2795 mm; Front Connection Length: 214 mm; Front Revolve Offset: 144 mm; Left Reference Line Length: 1467.5 mm; Pump Length: 517 mm; Rear Revolve Offset: 146 mm; Revolve Void Offset: 15 mm; Right Reference Line Length: 1952.5 mm; Safe Height: 172 mm; Safe Length: 3420 mm; Safe Width: 481.4 mm; Second Bracket: 2795 mm; Seventh Bracket: 0 mm; Sixth Bracket: 0 mm; Third Bracket: 2790 mm; Void Body Length: 2915 mm; Void Body Width: 461.4 mm
Pset_ManufacturerTypeInformation - Manufacturer: Mark
Constraints - Offset: 0 mm
Dimensions - Angle: 0 deg; Area: 13.4519 m2; Height: 40 mm; Volume: 0.131287 m3
Identity Data - Mark: 4
Mechanical - System Classification: Exhaust Air,Power,Supply Air
Mechanical - Flow - Exhaust Air Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Angle Safe: 0 deg; Family: HC_Radiant Heater_MEPcontent_Mark_Infra Mono_INT-EN: INFRA MONO 30-12; Family and Type: HC_Radiant Heater_MEPcontent_Mark_Infra Mono_INT-EN: INFRA MONO 30-12; Height Safe: 400 mm; Pendant Height: 89 mm; Pendant Length: 12.5 mm; Pendant Length 2: 21.25 mm; Second Pendant Length: 4.946 mm; Second Pendant Length 2: 33.75 mm; Type: HC_Radiant Heater_MEPcontent_Mark_Infra Mono_INT-EN: INFRA MONO 30-12; Type Id: HC_Radiant Heater_MEPcontent_Mark_Infra Mono_INT-EN: INFRA MONO 30-12; Void Angle: 1 deg; Void Height: 250 mm
Phasing - Phase Created: 4. Plan over 10 jaar
